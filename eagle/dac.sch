File: eagle/dac.sch (EAGLE design)
At the start: 0 parts

Commit message: usb interface and dac were separated
Other:
- note removed: "AC-DC converter +-12-15V"
