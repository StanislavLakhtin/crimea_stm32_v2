# Repository StanislavLakhtin/crimea_stm32_v2

File README.md:

# crimea_stm32_v2
The second version of the usb audio headphone amplifier based on PCM2707 and stm32

## EAGLE design eagle/power_supply.brd

Parts:
B1, B2: MB6S; SOIC-4
C_IN+5, C_IN+12: 10uF; EIA3216
C_IN-5, C_IN-12: 10uF; EIA3216
C_OUT+5, C_OUT+12: 30uF; CPOL-RADIAL-100UF-25V
C_OUT-5, C_OUT-12: 22uF; CPOL-RADIAL-100UF-25V
J1: CONN_04LONGPADS; 1X04_LONGPADS
J2: CONN_05PTH_LONGPADS; 1X05_LONGPADS
J3: CONN_02POLAR; MOLEX-1X2
J4: CONN_01; 1X01
L1, L2, L3, L4: INDUCTOR1206H*; INDUCTOR-1206
R1, R2, R7, R10: 10K; 0805
R3, R5: 23K; 0805
R4, R6, R9, R12: 2.7K; 0805
R8, R11: 7.9K; 0805
U1, U3: LM2991; DDPAK/TO-263
U2, U4: LM2941; DDPAK/TO-263

Connections:
5V_!ON!/OFF: J3.1, R7.2, R10.2, U3.2 (!ON!/OFF), U4.2 (!ON!/OFF)
+5V: C_OUT+5.1 (+), J2.1, L4.P$2 (2)
+12V: C_OUT+12.1 (+), J2.2, L2.P$2 (2)
+-12_!ON!/OFF: J3.2, R1.2, R2.2, U1.2 (!ON!/OFF), U2.2 (!ON!/OFF)
-5V: C_OUT-5.2 (-), J2.5, L3.P$2 (2)
-12V: C_OUT-12.2 (-), J2.4, L1.P$2 (2)
AGND: B1.-, B2.+, C_IN+5.C (-), C_IN+12.C (-), C_IN-5.A (+), C_IN-12.A (+), C_OUT+5.2 (-), C_OUT+12.2 (-), C_OUT-5.1 (+), C_OUT-12.1 (+), J2.3, J4.1, R1.1, R2.1, R4.1, R6.1, R7.1, R9.1, R10.1, R12.1, U1.4 (GND), U2.3 (GND), U2.TAB (GND), U3.4 (GND), U4.3 (GND), U4.TAB (GND)
unnamed: B2.-, C_IN-5.C (-), C_IN-12.C (-), U1.3 (IN), U1.TAB (IN), U3.3 (IN), U3.TAB (IN)
unnamed: R8.1, R9.2, U3.1 (ADJ)
unnamed: L3.P$1 (1), R8.2, U3.5 (OUT)
unnamed: L2.P$1 (1), R3.2, U2.5 (OUT)
unnamed: B1.+, C_IN+5.A (+), C_IN+12.A (+), U2.4 (IN), U4.4 (IN)
unnamed: B2.~1 (AC1), J1.2
unnamed: R3.1, R4.2, U2.1 (ADJ)
unnamed: L1.P$1 (1), R5.2, U1.5 (OUT)
unnamed: R5.1, R6.2, U1.1 (ADJ)
unnamed: R11.1, R12.2, U4.1 (ADJ)
unnamed: L4.P$1 (1), R11.2, U4.5 (OUT)
unnamed: B1.~2 (AC2), J1.3
~15V_MINUS: B2.~2 (AC2), J1.1
~15V_PLUS: B1.~1 (AC1), J1.4

Notes on the sheet:
AC-DC converter +-12-15V
LM2941: Vref=1.275 R11 = R12 * (Vout/Vref - 1) R3 = R4 * (Vout/Vref - 1) LM2991: Vout = Vref× (1+ R2/R1 )-(Iadj*R2)

Board: 2 copper layers, 46.0 x 61.0 mm, 34 parts (0 on the bottom side), 21 nets.

## EAGLE design eagle/usb.brd

Parts:
C1, C2, C5: 10uF; CPOL-RADIAL-100UF-25V
C3, C4, C13: 0.1uF; 1206
C6, C7: 1uF; 1206
C8, C9, C12: 100uF; CPOL-RADIAL-100UF-25V
C10, C11: 0.022uF; 1206
FB1: INDUCTOR1210; 1210
J1: PULLUP; 1X01
J2: AUDIO_JACK_TRS_0.25"; AUDIO_JACK_0.25"_TRS_PTH_RA
J3: SPI; 1X04
J4: I2S; MOLEX-1X6
J5: +3.3V; 1X02_LOCK_LONGPADS
J6: USB; USB-AB-MICRO-SMD
J7: +5V; 1X02_LOCK_LONGPADS
J8: !SUSPND!; 1X01
R1, R6: 1M; 0805
R2, R3: 22; 0805
R5, R7: 1.5K; 0805
R10, R11, R12, R13: 3.3K; 0805
R14, R15: 16; 0805
U2: LM3940IMP-3.3; SOT223
UK1: PCM2707; TQFP32-0.8-7X7MM
Y1: 12MHz; RESONATOR-SMD-3.2X1.3

Connections:
3.3V: C1.1 (+), C2.1 (+), C3.1, C4.1, C6.2, C7.1, FB1.2, J5.1, R7.1, UK1.2 (VCCP), UK1.10 (TEST), UK1.21 (VDD), UK1.24 (VBUS), UK1.27 (VCCL), UK1.30 (VCCR)
!SUSPEND!: J8.1, UK1.11 (!SSPND!)
+5V: C13.2, J7.2, U2.1 (IN)
BCK: J4.2, UK1.19 (FUNC1)
D+PULLPUP: J1.1, R5.1
DGND: C1.2 (-), C2.2 (-), C3.2, C4.2, C5.2 (-), C6.1, C7.2, C12.2 (-), C13.1, J2.SLEEVE (EARTH), J3.1, J4.1, J5.2, J6.GND1 (GND), J7.1, R1.1, R10.2, R11.2, R12.2, R13.2, R14.2, R15.2, U2.2 (GND), U2.4 (GND), UK1.1 (PGND), UK1.9 (FSEL), UK1.16 (PSEL), UK1.20 (DGND), UK1.25 (ZGND), UK1.26 (AGNDL), UK1.31 (AGNDR), Y1.2
DIN: J4.6, UK1.4 (FUNC3)
DOUT: J4.4, UK1.17 (DOUT)
LRCK: J4.5, UK1.5 (FUNC0)
unnamed: R6.1, UK1.12 (XTI), Y1.1
unnamed: C12.1 (+), FB1.1, U2.3 (OUT)
unnamed: R6.2, UK1.13 (XTO), Y1.3
unnamed: R2.1, UK1.23 (D+)
unnamed: R3.1, UK1.22 (D-)
unnamed: C5.1 (+), UK1.32 (VCOM)
unnamed: R7.2, UK1.15 (DT)
unnamed: C8.2 (-), J2.TIP, R10.1
unnamed: C9.2 (-), J2.RING, R11.1
unnamed: C10.1, R14.1
unnamed: C11.1, R15.1
SPI_!SS!: J3.2, UK1.6 (HID0/MS)
SPI_CLCK: J3.3, UK1.7 (HID1/MC)
SPI_MOSI: J3.4, UK1.8 (HID2/MD)
SYSCK: J4.3, UK1.18 (FUNC2)
USB_D+: J6.D+1 (D+), R2.2, R5.2
USB_D-: J6.D-1 (D-), R3.2
USB_VBUS: J6.VBUS1 (VBUS), R1.2, UK1.3 (HOST)
VOUT_L: C8.1 (+), C11.2, R13.1, UK1.28 (VOUTL)
VOUT_R: C9.1 (+), C10.2, R12.1, UK1.29 (VOUTR)

Board: 2 copper layers, 38.0 x 61.0 mm, 38 parts (0 on the bottom side), 29 nets.

Other parts of the board:
U$3: CRIMEA_TOP

## EAGLE design eagle/Crimea-v2.brd

Board: 4 copper layers, 160.0 x 100.0 mm, 93 parts (0 on the bottom side), 56 nets.

Parts:
DAC1:C1, DAC1:C2, DAC1:C6, DAC1:C9, DAC1:C10, DAC1:C12, DAC1:C19, DAC1:C20: 10uF; CPOL-RADIAL-100UF-25V
DAC1:C3, DAC1:C4, DAC1:C5, DAC1:C11, DAC1:C13, DAC1:C22, DAC1:C23: 0.1uF; 1206
DAC1:C7, DAC1:C8: 47uF; CPOL-RADIAL-100UF-25V
DAC1:C14, DAC1:C15, DAC1:C16, DAC1:C17: 2.7nF; 1206
DAC1:C18, DAC1:C21: 100uF; CPOL-RADIAL-100UF-25V
DAC1:IC1: OPA4134UA; SO14
DAC1:R1: 10K; 0805
DAC1:R2, DAC1:R3, DAC1:R4, DAC1:R5, DAC1:R6, DAC1:R7, DAC1:R8, DAC1:R10, DAC1:R11, DAC1:R12: 1K; 0805
DAC1:R9, DAC1:R13: 39.2; 0805
DAC1:U$1: PCM1794A; SSOP28-0.65-10.2X5.2MM
DAC1:U$6: TPA6120A2; SOIC20S
PCM2707-1:C1, PCM2707-1:C2, PCM2707-1:C5: 10uF; CPOL-RADIAL-100UF-25V
PCM2707-1:C3, PCM2707-1:C4: 0.1uF; 1206
PCM2707-1:C6, PCM2707-1:C7: 1uF; 1206
PCM2707-1:J1: 1X04_LONGPADS
PCM2707-1:R1, PCM2707-1:R6, PCM2707-1:R9: 1M; 0805
PCM2707-1:R2, PCM2707-1:R3: 22; 0805
PCM2707-1:R4: 400K; 0805
PCM2707-1:R5, PCM2707-1:R7, PCM2707-1:R8: 1.5K; 0805
PCM2707-1:U$1: PCM2707; TQFP32-0.8-7X7MM
PCM2707-1:U$2: IRLML2246TRPBF; SOT23-3
PCM2707-1:Y1: 12MHz CSTCE12MOG52-R0; RESONATOR-SMD-3.2X1.3
VR:B1, VR:B2: MB6S; SOIC-4
VR:C_IN+, VR:C_IN+1: 10uF; EIA3216-KIT
VR:C_IN-1, VR:C_IN-2: 10uF; EIA3216-KIT
VR:C_OUT+, VR:C_OUT+1: 10uF; EIA3216-KIT
VR:C_OUT-, VR:C_OUT-1: 10uF; EIA3216-KIT
VR:J1: 1X03_LONGPADS
VR:J2: 1X05_LONGPADS
VR:J3: MOLEX-1X2
VR:J4: 1X01
VR:L1, VR:L2, VR:L3, VR:L4: INDUCTOR-1206
VR:R1, VR:R2, VR:R7, VR:R10: 10K; 0805
VR:R3, VR:R5, VR:R8, VR:R11: 2.7K; 0805
VR:R4, VR:R6, VR:R9, VR:R12: ??; 0805
VR:U$1, VR:U$3: LM2991; DDPAK/TO-263
VR:U$2, VR:U$4: LM2941; DDPAK/TO-263

Connections:
DAC1:3.3V: DAC1:C2.1, DAC1:C4.2, DAC1:C10.2, DAC1:C11.1, DAC1:C12.1, DAC1:C13.1, DAC1:IC1.3, DAC1:IC1.5, DAC1:IC1.10, DAC1:IC1.12, DAC1:R7.1, DAC1:R10.1, DAC1:U$1.9
DAC1:5V: DAC1:C1.1, DAC1:C3.1, DAC1:C5.2, DAC1:C6.1, DAC1:C7.1, DAC1:C8.1, DAC1:C9.1, DAC1:U$1.15, DAC1:U$1.23, DAC1:U$1.28
DAC1:+12V: DAC1:C10.1, DAC1:C11.2, DAC1:C18.1, DAC1:C19.1, DAC1:C22.1, DAC1:IC1.4, DAC1:U$6.3, DAC1:U$6.18
DAC1:-12V: DAC1:C12.2, DAC1:C13.2, DAC1:C20.2, DAC1:C21.2, DAC1:C23.1, DAC1:IC1.11, DAC1:U$6.1, DAC1:U$6.20
DAC1:AGND: DAC1:C1.2, DAC1:C3.2, DAC1:C5.1, DAC1:C6.2, DAC1:C9.2, DAC1:C18.2, DAC1:C19.2, DAC1:C20.1, DAC1:C21.1, DAC1:C22.2, DAC1:C23.2, DAC1:R1.2, DAC1:U$1.16, DAC1:U$1.19, DAC1:U$1.24, DAC1:U$1.27
DAC1:DGND: DAC1:C2.2, DAC1:C4.1, DAC1:U$1.8
DAC1:N$1: DAC1:C14.2, DAC1:IC1.2, DAC1:R2.1, DAC1:U$1.26
DAC1:N$2: DAC1:C15.2, DAC1:IC1.6, DAC1:R3.1, DAC1:U$1.25
DAC1:N$3: DAC1:R1.1, DAC1:U$1.20
DAC1:N$4: DAC1:R6.2, DAC1:R7.2, DAC1:U$6.4
DAC1:N$5: DAC1:C7.2, DAC1:U$1.22
DAC1:N$6: DAC1:C8.2, DAC1:U$1.21
DAC1:N$8: DAC1:C14.1, DAC1:IC1.1, DAC1:R2.2, DAC1:R8.1, DAC1:U$6.5
DAC1:N$9: DAC1:R8.2, DAC1:R9.1, DAC1:U$6.2
DAC1:N$10: DAC1:R10.2, DAC1:R11.2, DAC1:U$6.17
DAC1:N$11: DAC1:R12.2, DAC1:R13.1, DAC1:U$6.19
DAC1:N$14: DAC1:C15.1, DAC1:IC1.7, DAC1:R3.2, DAC1:R6.1
DAC1:N$17: DAC1:C16.2, DAC1:IC1.9, DAC1:R4.1, DAC1:U$1.18
DAC1:N$20: DAC1:C16.1, DAC1:IC1.8, DAC1:R4.2, DAC1:R12.1, DAC1:U$6.16
DAC1:N$23: DAC1:C17.2, DAC1:IC1.13, DAC1:R5.1, DAC1:U$1.17
DAC1:N$25: DAC1:C17.1, DAC1:IC1.14, DAC1:R5.2, DAC1:R11.1
PCM2707-1:3.3V: PCM2707-1:C1.1, PCM2707-1:C2.1, PCM2707-1:C3.1, PCM2707-1:C4.1, PCM2707-1:C6.2, PCM2707-1:C7.1, PCM2707-1:R7.1, PCM2707-1:R8.2, PCM2707-1:U$1.2, PCM2707-1:U$1.21, PCM2707-1:U$1.27, PCM2707-1:U$1.30
PCM2707-1:DGND: PCM2707-1:C1.2, PCM2707-1:C2.2, PCM2707-1:C3.2, PCM2707-1:C4.2, PCM2707-1:C5.2, PCM2707-1:C6.1, PCM2707-1:C7.2, PCM2707-1:J1.4, PCM2707-1:R1.1, PCM2707-1:U$1.1, PCM2707-1:U$1.9, PCM2707-1:U$1.16, PCM2707-1:U$1.20, PCM2707-1:U$1.25, PCM2707-1:U$1.26, PCM2707-1:U$1.31, PCM2707-1:Y1.2
PCM2707-1:N$1: PCM2707-1:R6.1, PCM2707-1:U$1.12, PCM2707-1:Y1.1
PCM2707-1:N$2: PCM2707-1:R5.1, PCM2707-1:U$2.3
PCM2707-1:N$3: PCM2707-1:R6.2, PCM2707-1:U$1.13, PCM2707-1:Y1.3
PCM2707-1:N$4: PCM2707-1:R2.1, PCM2707-1:U$1.23
PCM2707-1:N$5: PCM2707-1:R3.1, PCM2707-1:U$1.22
PCM2707-1:N$6: PCM2707-1:C5.1, PCM2707-1:U$1.32
PCM2707-1:N$7: PCM2707-1:R7.2, PCM2707-1:U$1.15
PCM2707-1:N$8: PCM2707-1:R8.1, PCM2707-1:U$1.10
PCM2707-1:N$9: PCM2707-1:R9.2, PCM2707-1:U$1.3
PCM2707-1:PULLUP_HANDLE: PCM2707-1:R4.2, PCM2707-1:U$2.1
PCM2707-1:USB_D+: PCM2707-1:J1.2, PCM2707-1:R2.2, PCM2707-1:R5.2
PCM2707-1:USB_D-: PCM2707-1:J1.3, PCM2707-1:R3.2
PCM2707-1:USB_VBUS: PCM2707-1:J1.1, PCM2707-1:R1.2, PCM2707-1:R4.1, PCM2707-1:R9.1, PCM2707-1:U$1.24, PCM2707-1:U$2.2
VR:5V_!ON!/OFF: VR:J3.1, VR:R7.2, VR:R10.2, VR:U$3.2, VR:U$4.2
VR:+5V: VR:C_OUT+1.A, VR:J2.1, VR:L4.P$2
VR:+12V: VR:C_OUT+.A, VR:J2.2, VR:L2.P$2
VR:+-12_!ON!/OFF: VR:J3.2, VR:R1.2, VR:R2.2, VR:U$1.2, VR:U$2.2
VR:-5V: VR:C_OUT-1.C, VR:J2.5, VR:L3.P$2
VR:-12V: VR:C_OUT-.C, VR:J2.4, VR:L1.P$2
VR:AGND: VR:B1.-, VR:B2.-, VR:C_IN+.C, VR:C_IN+1.C, VR:C_IN-1.A, VR:C_IN-2.A, VR:C_OUT+.C, VR:C_OUT+1.C, VR:C_OUT-.A, VR:C_OUT-1.A, VR:J2.3, VR:J4.1, VR:R1.1, VR:R2.1, VR:R4.1, VR:R6.1, VR:R7.1, VR:R9.1, VR:R10.1, VR:R12.1, VR:U$1.4, VR:U$2.3, VR:U$2.TAB, VR:U$3.4, VR:U$4.3, VR:U$4.TAB
VR:EXTGND: VR:B1.~2, VR:B2.~1, VR:J1.2
VR:N$1: VR:B2.+, VR:C_IN-1.C, VR:C_IN-2.C, VR:U$1.3, VR:U$1.TAB, VR:U$3.3, VR:U$3.TAB
VR:N$2: VR:R8.1, VR:R9.2, VR:U$3.1
VR:N$3: VR:L3.P$1, VR:R8.2, VR:U$3.5
VR:N$4: VR:L2.P$1, VR:R3.2, VR:U$2.5
VR:N$5: VR:B1.+, VR:C_IN+.A, VR:C_IN+1.A, VR:U$2.4, VR:U$4.4
VR:N$7: VR:R3.1, VR:R4.2, VR:U$2.1
VR:N$8: VR:L1.P$1, VR:R5.2, VR:U$1.5
VR:N$9: VR:R5.1, VR:R6.2, VR:U$1.1
VR:N$10: VR:R11.1, VR:R12.2, VR:U$4.1
VR:N$11: VR:L4.P$1, VR:R11.2, VR:U$4.5
VR:~15V_MINUS: VR:B2.~2, VR:J1.1
VR:~15V_PLUS: VR:B1.~1, VR:J1.3

## EAGLE design eagle/dac-_.brd

Parts:
C1, C2, C6, C9, C12, C19, C20: 10uF; CPOL-RADIAL-100UF-25V
C3, C4, C5, C11, C13, C22, C23: 0.1uF; 1206
C8: 47uF; CPOL-RADIAL-100UF-25V
C14, C15, C16, C17: 2.7nF; 1206
C18, C21: 100uF; CPOL-RADIAL-100UF-25V
IC1: OPA4134UA; SO14
J1: I2S; 1X05
J2, J3: CONN_03POLAR; MOLEX-1X3
J4: CONN_02POLAR_LOCK; MOLEX-1X2_LOCK
J5: +3.3V; MOLEX-1X2
J6: 5V/GND/-5V; 1X03_LONGPADS
J7: 12V/GND/-12V; 1X03_LONGPADS
J8: AUDIO_JACK_TRS_0.25"_PTH_RA; AUDIO_JACK_0.25"_TRS_PTH_RA
R1: 10K; 0805
R2, R3, R4, R5, R6, R7, R8, R10, R11, R12, R15, R17: 1K; 0805
R9, R13: 39.2; 0805
R14, R16, R18, R20: 27; 0805
UK1: PCM1794A; SSOP28-0.65-10.2X5.2MM
UK2: TPA6120A2; SOIC20S

Connections:
3.3V: C2.1 (+), C4.2, J5.1, UK1.9 (VDD)
5V: C1.1 (+), C3.1, C5.2, C6.1 (+), C8.1 (+), C9.1 (+), C11.2, IC1.4 (V+), J6.3, UK1.15 (VCC2R), UK1.23 (VCC1), UK1.28 (VCC2L)
!RST!: J4.1, UK1.14 (!RST!)
+12V: C18.1 (+), C19.1 (+), C22.1, J7.3, UK2.3 (LVCC+), UK2.18 (RVCC+)
-5V: C12.2 (-), C13.2, IC1.11 (V-), J6.1
-12V: C20.2 (-), C21.2 (-), C23.1, J7.1, UK2.1 (LVCC-), UK2.20 (RVCC-)
BCK: R18.2, UK1.6 (BCK)
CHSL: J2.2, UK1.2 (CHSL)
DATA: R16.2, UK1.5 (DATA)
DEM: J2.1, UK1.3 (DEM)
DGND: C1.2 (-), C2.2 (-), C3.2, C4.1, C5.1, C6.2 (-), C9.2 (-), C11.1, C12.1 (+), C13.1, C18.2 (-), C19.2 (-), C20.1 (+), C21.1 (+), C22.2, C23.2, IC1.3 (+IN), IC1.5 (+IN), IC1.10 (+IN), IC1.12 (+IN), J1.1, J5.2, J6.2, J7.2, J8.SLEEVE (EARTH), R1.2, R7.1, R10.1, UK1.8 (DGND), UK1.16 (AGND3R), UK1.19 (AGND1), UK1.24 (AGND2), UK1.27 (AGND3L)
FMT0: J3.2, UK1.11 (FMT0)
FMT1: J3.1, UK1.12 (FMT1)
LOUT: J8.TIP, R9.2
LRCK: R14.2, UK1.4 (LRCK)
MONO: J2.3, UK1.1 (MONO)
MUTE: J3.3, UK1.10 (MUTE)
unnamed: C15.2, IC1.6 (-IN), R3.1, UK1.26 (IOUTL-)
unnamed: C14.2, IC1.2 (-IN), R2.1, UK1.25 (IOUTL+)
unnamed: R1.1, UK1.20 (IREF)
unnamed: R6.2, R7.2, UK2.4 (LIN+)
unnamed: C14.1, IC1.1 (OUT), R2.2, R6.1
unnamed: C8.2 (-), UK1.21 (VCOMR), UK1.22 (VCOML)
unnamed: J1.5, R14.1
unnamed: C15.1, IC1.7 (OUT), R3.2, R15.1
unnamed: R8.2, R9.1, UK2.2 (LOUT)
unnamed: R10.2, R11.2, UK2.17 (RIN+)
unnamed: R12.2, R13.1, UK2.19 (ROUT)
unnamed: C16.1, IC1.8 (OUT), R4.2, R11.1
unnamed: J1.4, R16.1
unnamed: C16.2, IC1.9 (-IN), R4.1, UK1.17 (IOUTR+)
unnamed: R8.1, R15.2, UK2.5 (LIN-)
unnamed: J1.3, R18.1
unnamed: C17.2, IC1.13 (-IN), R5.1, UK1.18 (IOUTR-)
unnamed: R12.1, R17.2, UK2.16 (RIN-)
unnamed: J1.2, R20.1
unnamed: C17.1, IC1.14 (OUT), R5.2, R17.1
ROUT: J8.RING, R13.2
SYSCK: R20.2, UK1.7 (SCK)
ZERO: J4.2, UK1.13 (ZERO)

Notes on the sheet:
I/V Stage

Board: 4 copper layers, 50.0 x 61.0 mm, 51 parts (0 on the bottom side), 40 nets.

## Commit log

2018-05-09 pcm2707 schematic pre finished
2018-05-09 pcm2707 DGND error fixed
2018-05-09 pcm2707 HOST pullup resistor was added
2018-05-09 minor changes
2018-05-12 inverter deleted. dac added. it is not finished yet
2018-05-13 added +-5V reg
2018-05-13 power supply board added
2018-05-13 power supply board is finished
2018-05-13 power supply finished
2018-05-14 repaint power supply
2018-05-14 power supply test board has finished
2018-05-20 usb interface and dac were separated
2018-05-20 pre usb interface gamma
2018-05-20 beta usb interface
2018-05-21 some minor changes
2018-05-24 some impr
2018-05-24 switched to 4 layer pcb
2018-05-24 4 layer PCB draft
2018-05-25 swap layers
2018-06-01 repaint board

Notices in the files:
parts and their libraries:
SparkFun-Connectors: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
